# Keil uVision project Lcd12864.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Lcd12864 +hex
  c flags: Optimize=6 SizeSpeed=1
  group Source Files
    ../source/: STARTUP.A51 main.c Lcd12864.c
  group Head Files
    ../source/: config.h main.h Lcd12864.h
