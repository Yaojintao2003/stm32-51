# Keil uVision project AllTest.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: AllTest +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\source
  group SourceFiles
    ../source/: Lcd1602.c LedBuzzer.c keyboard.c DS1302.c DS18B20.c Infrared.c main.c Uart.c eeprom.c I2C.c PCF8591.c STARTUP.A51
  group IncludeFiles
    ../source/: config.h Lcd1602.h LedBuzzer.h keyboard.h DS1302.h DS18B20.h Infrared.h main.h Uart.h eeprom.h I2C.h PCF8591.h
