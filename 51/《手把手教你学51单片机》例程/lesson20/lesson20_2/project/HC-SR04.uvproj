# Keil uVision project HC-SR04.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: HC-SR04 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\source
  group Source Group 1
    ../source/: STARTUP.A51 main.c Lcd1602.c Ultrasonic.c
