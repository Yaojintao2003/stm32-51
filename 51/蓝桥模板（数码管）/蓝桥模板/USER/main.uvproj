# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: main +hex (library)
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\CODE;..\SYS;..\USER
  group Source Group 1
    ./: STARTUP.A51
  group USER
    ./: main.c
  group CODE
    ../CODE/: csb.c ds18b20.c eeprom.c key.c pcf8591.c shuma.c usart1.c
  group SYS
    ../SYS/: iic.c base.c
